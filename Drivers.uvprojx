# Keil uVision project Drivers.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Drivers
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: stm_drivers.h stm_drivers.c lcd.c lcd.h util.h util.c tetris.c tetris.h input_pad.c input_pad.h
  group New Group
    ./: main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
